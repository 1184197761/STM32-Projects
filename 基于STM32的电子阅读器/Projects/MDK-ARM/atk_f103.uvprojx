# Keil uVision project atk_f103.uvprojx, settings and files
target E-Reader (6190000::V6.19::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User\;..\..\Middlewares;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Middlewares\emWin\Config;..\..\Middlewares\emWin\inc;..\..\Middlewares\emWin\emWin_Demo;..\..\User\codegentemp;..\..\Drivers\BSP\KEY;..\..\Drivers\BSP\TPAD;..\..\Drivers\BSP\BEEP;..\..\Drivers\BSP\RTC;..\..\Drivers\BSP\ADC;..\..\Drivers\BSP\LSENS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c Chinese_12.c Chinese_16.c Chinese_20.c E_Reader.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../../Drivers/BSP/TPAD/: tpad.c
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/ADC/: adc.c adc3.c
    ../../Drivers/BSP/LSENS/: lsens.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/emWin/Config
    ../../Middlewares/emWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf.c
  group Middlewares/emWin/Lib
    ../../Middlewares/emWin/Lib/: GUI_CM3_L.lib
  group Middlewares/emWin/OS
    ../../Middlewares/emWin/OS/: GUI_X_FreeRTOS.c
  group Middlewares/emWin/emWin_Demo
    ../../Middlewares/emWin/emWin_Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Touch.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Readme
    ../../: readme.txt
